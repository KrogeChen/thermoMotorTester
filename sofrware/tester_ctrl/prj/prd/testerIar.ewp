# IAR project testerIar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ; ..\pbc\pbc_Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\pbc\pbc_Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: testerIar.srec
  ILINK.IlinkOutputFile: testerIar.out
  ILINK.IlinkIcfFile: app_stm32f103rct6.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: testerIar.bin
  group app
    ../app/: app_cfg.h app_electricmeter.c app_electricmeter.h app_general.c app_general.h app_grating.c app_grating.h app_modbus.c app_modbus.h app_pt100.c app_pt100.h app_storage.c app_storage.h app_thermo.c app_thermo.h main.c
  group mde/mde_digitInput
    ../mde/mde_digitInput/: mde_digitInput.c mde_digitInput.h
  group mde/mde_digitInput/depend
    ../mde/mde_digitInput/depend/: bsp_digitInput.c bsp_digitInput.h
  group mde/mde_digitOutput
    ../mde/mde_digitOutput/: mde_digitOutput.c mde_digitOutput.h
  group mde/mde_digitOutput/depend
    ../mde/mde_digitOutput/depend/: bps_digitOutput.h bsp_digitOutput.c
  group mde/mde_grating
    ../mde/mde_grating/: mde_grating.c mde_grating.h
  group mde/mde_grating/depend
    ../mde/mde_grating/depend/: bps_grating.h bsp_grating.c
  group mde/mde_keyboard
    ../mde/mde_keyboard/: mde_keyboard.c mde_keyboard.h
  group mde/mde_keyboard/depend
    ../mde/mde_keyboard/depend/: bsp_keyboard.c bsp_keyboard.h
  group mde/mde_ledBlink
    ../mde/mde_ledBlink/: mde_ledBlink.c mde_ledBlink.h
  group mde/mde_ledBlink/depend
    ../mde/mde_ledBlink/depend/: bsp_ledBlink.c bsp_ledBlink.h
  group mde/mde_mRtuMaster
    ../mde/mde_mRtuMaster/: mde_mRtuMaster.c mde_mRtuMaster.h
  group mde/mde_mRtuMaster/depend
    ../mde/mde_mRtuMaster/depend/: bsp_mRtuMaster.c bsp_mRtuMaster.h
  group mde/mde_mRtuSlave
    ../mde/mde_mRtuSlave/: mde_mRtuSlave.c mde_mRtuSlave.h
  group mde/mde_mRtuSlave/depend
    ../mde/mde_mRtuSlave/depend/: bsp_mRtuSlave.c bsp_mRtuSlave.h snail_data_types.h snail_macro.h
  group mde/mde_mutilpt100
    ../mde/mde_mutlipt100/: mde_mutilpt100.c mde_mutilpt100.h
  group mde/mde_mutilpt100/depend
    ../mde/mde_mutlipt100/depend/: bsp_mutilpt100.c bsp_mutilpt100.h
  group mde/mde_stroage
    ../mde/mde_storage32bits/: mde_storage32bits.c mde_storage32bits.h
  group mde/mde_stroage/depend
    ../mde/mde_storage32bits/depend/: bsp_flashMemory.c bsp_flashMemory.h
  group mde/mde_sysClock
    ../mde/mde_sysClock/: mde_system_clock.c mde_system_clock.h
  group mde/mde_sysClock/depend
    ../mde/mde_sysClock/depend/: bps_system_clock.c bps_system_clock.h snail_data_types.h
  group mde/mde_watchdog
    ../mde/mde_watchdog/: mde_watchdog.c mde_watchdog.h
  group mde/mde_watchdog/depend
    ../mde/mde_watchdog/depend/: bsp_watchdog.c bsp_watchdog.h
  group pbc/pbc_crc16
    ../pbc/pbc_crc16/: pbc_crc16.c pbc_crc16.h
  group pbc/pbc_crc16/depend
    ../pbc/pbc_crc16/depend/: snail_data_types.h
  group pbc/pbc_dataConvert
    ../pbc/pbc_dataConvert/: pbc_dataConvert.c pbc_dataConvert.h
  group pbc/pbc_libraries
    ../pbc/pbc_Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group pbc/pbc_libraries/cmsis
    ../pbc/pbc_Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c
    ../pbc/pbc_Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    ./: system_stm32f10x.c
  group pbc/pbc_sysTick
    ../pbc/pbc_sysTick/: pbc_sysTick.c pbc_sysTick.h
  group pbc/pbc_sysTick/depend
    ../pbc/pbc_sysTick/depend/: bsp_sysTick.c bsp_sysTick.h
